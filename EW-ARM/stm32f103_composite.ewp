# IAR project stm32f103_composite.ewp, settings and files
configuration STM32F103RC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f103_composite.bin
  ILINK.IlinkOutputFile: stm32f103_composite.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F103RB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; HSE_VALUE=8000000
  ILINK.IlinkIcfFile: stm32f103_composite.icf
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
    ../src/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: hw_config.c main.c mass_diskio.c memory.c scsi_data.c stm32_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
